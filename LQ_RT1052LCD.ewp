# IAR project LQ_RT1052LCD.ewp, settings and files
configuration sdram_debug (ARM, debug)
  General.OGChipSelectEditMenu: MIMXRT1052xxx6A NXP MIMXRT1052xxx6A
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  General.CoreVariant: 41
  General.FPU2: 7
  ICCARM.CCDefines: SKIP_SYSCLK_INIT; SDRAM_MPU_INIT; DEBUG; CPU_MIMXRT1052DVL6B; PRINTF_FLOAT_ENABLE=0; SCANF_FLOAT_ENABLE=0; PRINTF_ADVANCED_ENABLE=0; SCANF_ADVANCED_ENABLE=0; SDK_I2C_BASED_COMPONENT_USED=1; _DLIB_FILE_DESCRIPTOR
  ICCARM.CCDiagSuppress: Pa082,Pa050,Pe167
  ICCARM.CCIncludePath2: LQuserFlies\src; LQuserFlies\src\board; LQuserFlies\src\camera; LQuserFlies\src\touch; LQuserFlies\devices\; LQuserFlies\devices\drivers; LQuserFlies\devices\utilities; LQuserFlies\devices\startup; LQuserFlies\CMSIS; LQuserFlies\middleware\fatfs; LQuserFlies\middleware\libjpeg; LQuserFlies\middleware\TF; LQuserFlies\middleware\usb; LQuserFlies\middleware\usb\device; LQuserFlies\middleware\usb\host; LQuserFlies\middleware\usb\host\class; LQuserFlies\middleware\usb\include; LQuserFlies\middleware\usb\osa; LQuserFlies\middleware\usb\phy; LQuserFlies\middleware\dma_manager; LQuserFlies\src\sys; LQuserFlies\src\ANO_DT
  ICCARM.CCOptLevel: 2
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  AARM.ADefines: DEBUG; __STARTUP_INITIALIZE_NONCACHEDATA
  OBJCOPY.OOCOutputFile: LQ_RT1052LCD.srec
  ILINK.IlinkOutputFile: elcdif_rgb.out
  ILINK.IlinkIcfFile: LQuserFlies\config\LQ_RT1052SDRAM_Boot.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration sdram_release (ARM)
  as the first configuration, except:
  ICCARM.CCDefines: LQRELEASE; DEBUG; SKIP_SYSCLK_INIT; SDRAM_MPU_INIT; CPU_MIMXRT1052DVL6B; PRINTF_FLOAT_ENABLE=0; SCANF_FLOAT_ENABLE=0; XIP_EXTERNAL_FLASH=1; PRINTF_ADVANCED_ENABLE=0; SCANF_ADVANCED_ENABLE=0; SDK_I2C_BASED_COMPONENT_USED=1; XIP_EXTERNAL_FLASH=1; XIP_BOOT_HEADER_ENABLE=1; XIP_BOOT_HEADER_DCD_ENABLE=0; _DLIB_FILE_DESCRIPTOR
  ICCARM.CCIncludePath2: LQuserFlies\src; LQuserFlies\src\board; LQuserFlies\src\camera; LQuserFlies\src\touch; LQuserFlies\devices\; LQuserFlies\devices\drivers; LQuserFlies\devices\utilities; LQuserFlies\devices\startup; LQuserFlies\CMSIS; LQuserFlies\middleware\fatfs; LQuserFlies\middleware\libjpeg; LQuserFlies\middleware\TF; LQuserFlies\middleware\usb; LQuserFlies\middleware\usb\device; LQuserFlies\middleware\usb\host; LQuserFlies\middleware\usb\host\class; LQuserFlies\middleware\usb\include; LQuserFlies\middleware\usb\osa; LQuserFlies\middleware\usb\phy; LQuserFlies\middleware\dma_manager; LQuserFlies\src\sys; LQuserFlies\src\ANO_DT; D:\nxp\driver; D:\nxp\system
  ICCARM.CCOptLevel: 1
  AARM.ADefines: __STARTUP_INITIALIZE_NONCACHEDATA
  OBJCOPY.OOCOutputFile: LQ_RT1052LCD.bin
  ILINK.IlinkOutputFile: $PROJ_FNAME$.bin
  ILINK.IlinkKeepSymbols: image_vector_table; boot_data; dcd_data
  ILINK.IlinkConfigDefines: __stack_size__=0x8000; __heap_size__=0x100000
  ILINK.IlinkIcfFile: LQuserFlies\config\LQ_RT1052QSPI_Boot.icf
  group board
    LQuserFlies/src/board/: board.c board.h clock_config.c clock_config.h pin_mux.c pin_mux.h
    LQuserFlies/devices/: MIMXRT1052.h MIMXRT1052_features.h
  group driver
    driver/: base.c oled.c uart.c
  group fsl_lib
    LQuserFlies/devices/drivers/: fsl_adc.c fsl_adc.h fsl_clock.c fsl_clock.h fsl_common.c fsl_common.h fsl_csi.c fsl_csi.h fsl_dmamux.c fsl_dmamux.h fsl_edma.c fsl_edma.h fsl_elcdif.c fsl_elcdif.h fsl_enc.c fsl_flexio.c fsl_flexio.h fsl_flexio_spi.c fsl_flexio_spi.h fsl_flexio_spi_edma.c fsl_flexio_spi_edma.h fsl_flexspi.c fsl_flexspi.h fsl_gpio.c fsl_gpio.h fsl_gpt.c fsl_gpt.h fsl_iomuxc.h fsl_lpi2c.c fsl_lpi2c.h fsl_lpspi.c fsl_lpspi.h fsl_lpuart.c fsl_lpuart.h fsl_lpuart_edma.c fsl_lpuart_edma.h fsl_pit.c fsl_pit.h fsl_pwm.c fsl_pwm.h fsl_pxp.c fsl_pxp.h fsl_qtmr.c fsl_qtmr.h fsl_semc.c fsl_semc.h fsl_trng.c fsl_trng.h fsl_usdhc.c fsl_usdhc.h fsl_wdog.c fsl_wdog.h fsl_xbara.c fsl_xbara.h
  group LQDriver
    LQuserFlies/src/: LQ_9AX.c LQ_9AX.h LQ_9AXtest.c LQ_ADC.c LQ_ADC.h LQ_CSI.c LQ_CSI.h LQ_Encoder.c LQ_Encoder.h LQ_GPIOmacro.h LQ_IIC.c LQ_IIC.h LQ_MPU6050.c LQ_MPU6050.h LQ_NRF2401.c LQ_NRF2401.h LQ_PIT.c LQ_PIT.h LQ_PWM.c LQ_PWM.h LQ_PXP.c LQ_PXP.h LQ_QTMR.c LQ_QTMR.h LQ_SGP18Test.c LQ_SGP18Test.h LQ_SPI.c LQ_SPI.h LQ_TRNG.c LQ_TRNG.h LQ_WDog.c LQ_WDog.h
  group LQDriver/AHRS
    LQuserFlies/src/sys/: AHRS.c AHRS.h AP_Math.c AP_Math.h Inertial_Sensor.c Inertial_Sensor.h
  group LQDriver/ANO_TC
    LQuserFlies/src/ANO_DT/: ANO_DT.c ANO_DT.h
  group LQDriver/Camera
    LQuserFlies/src/camera/: fsl_camera.h fsl_camera_device.h fsl_camera_receiver.h fsl_csi_camera_adapter.c fsl_csi_camera_adapter.h fsl_sccb.c fsl_sccb.h fsl_video_common.h LQ_MT9V034M.c LQ_MT9V034M.h LQ_OV7725M.c LQ_OV7725M.h
  group LQDriver/SDCard
    LQuserFlies/src/: LQ_12864.h
  group LQDriver/Sys
    LQuserFlies/src/sys/: m_systime.c m_systime.h status.c status.h
  group startup
    LQuserFlies/devices/startup/: startup_MIMXRT1052.s system_MIMXRT1052.c system_MIMXRT1052.h
  group system
    system/: main.c system.c
  group utilities
    LQuserFlies/devices/utilities/: fsl_assert.c fsl_debug_console.c fsl_debug_console.h fsl_debug_console_conf.h fsl_io.c fsl_io.h fsl_log.c fsl_log.h fsl_str.c fsl_str.h
  group XIP
    LQuserFlies/Xip/: external_flash_config.h fsl_flexspi_nor_boot.c fsl_flexspi_nor_boot.h xip_config.c
